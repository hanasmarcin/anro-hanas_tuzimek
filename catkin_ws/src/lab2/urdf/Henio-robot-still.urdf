Commit message: Add files via upload

File: catkin_ws/src/lab2/urdf/Henio-robot-still.urdf (robot description, URDF)
Before this commit: robot Henio-robot, 5 links, 4 joints
Joints:
- joint 2 z czlonem: origin xyz=0 0 0 -> xyz=0 0 0 rpy=${props['i3']['j_rpy']}
